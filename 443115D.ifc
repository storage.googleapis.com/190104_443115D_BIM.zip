Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-31T16:34:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 31 16:34:42 2021 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{10F9C17B-74F8-4E14-B712-4000887271A1}\ifc * Database version: 5507 * Database creation date: Tue Aug 31 16:34:42 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 31 16:34:42 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 31 16:34:42 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowController: 443115D Radiator valve body, DN15, L=26, H=24, 443115D:443115D Radiator valve body, DN15, L=26, H=24:324584
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 33.5014 mm; NominalHeight: 65.8515 mm; NominalWidth: 42.7455 mm
Type - General - Author: BIMstone; BIMObjectName: 443115D; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 06/08/2021
Type - Green Building Properties - Customs Code: 84818031; EAN Number: 6414150098192; EN Standard: EN 215; LVI Number: 4032054
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/443115D; Catalog Drawing URL: http://static.oras.com/catdrw/443115D; Dimension Drawing URL: http://static.oras.com/dimdrw/443115D; FDV Document URL: http://www.oras.com/datasheet/443115D/en/fdv; Group: RadiatorValve; Manufacturer: Oras; Model: 443115D Radiator valve body, DN15, L=26, H=24; Name_en: 443115D Radiator valve body, DN15, L=26, H=24; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 0.191 kg; Product Code: 443115D; Product Datasheet: http://www.oras.com/datasheet/443115D/en; Product Family: Oras; Product Image URL: http://static.oras.com/image/443115D; Product URL: http://static.oras.com/443115D; Technical DataSheet URL: http://www.oras.com/datasheet/443115D/en; Type Name: 443115D Radiator valve body, DN15, L=26, H=24
Type - Materials and Finishes - FaucetMainMaterial: Brass; FaucetSecondaryMaterial: Red
Type - Mechanical - Connection: InternalThread; Connection Size: G1/2; DN Size: DN15; Installation and Maintenance: http://static.oras.com/manual/443115D; Max. Hot Water Supply: 110 kg/K/s3
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 443115D; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 443115D; Name: 443115D Radiator valve body, DN15, L=26, H=24; ReplacementCost: n/a; Shape: Sculptured; Size: 43x34x65 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.00645301 m2; InletConnectionSize: 15 mm; InletDistance: 150 mm; InletRadius: 7.5 mm; Volume: 0.0000943016 m3
Identity Data - Mark: 19
Mechanical - System Classification: Hydronic Supply
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 443115D: 443115D Radiator valve body, DN15, L=26, H=24; Family and Type: 443115D: 443115D Radiator valve body, DN15, L=26, H=24; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 443115D: 443115D Radiator valve body, DN15, L=26, H=24; Type Id: 443115D: 443115D Radiator valve body, DN15, L=26, H=24; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
